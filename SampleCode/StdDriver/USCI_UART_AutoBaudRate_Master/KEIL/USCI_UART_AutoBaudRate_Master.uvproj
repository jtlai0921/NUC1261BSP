# Keil uVision project USCI_UART_AutoBaudRate_Master.uvproj, settings and files
target USCI_UART_AutoBaudRate_Master (ARM-ADS)
  device: NUC126VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USCI_UART_AutoBaudRate_Master
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC1261\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
    ../../../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c usci_uart.c uart.c sys.c
