# IAR project PWM_PDMA_Capture.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1261AE series Nuvoton NUC1261AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1261\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_PDMA_Capture.bin
  ILINK.IlinkOutputFile: PWM_PDMA_Capture.out
  ILINK.IlinkIcfFile: PWM_PDMA_Capture.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1261/Source/IAR/: startup_NUC1261.s
    ../../../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c pwm.c retarget.c sys.c uart.c
  group User
    ../: main.c
