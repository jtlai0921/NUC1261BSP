# IAR project USBD_MassStorage_DataFlash.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1261AE series Nuvoton NUC1261AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1261\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_MassStorage_DataFlash.bin
  ILINK.IlinkOutputFile: MSC.out
  ILINK.IlinkIcfFile: USBD_MassStorage_DataFlash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1261/Source/IAR/: startup_NUC1261.s
    ../../../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c usbd.c
  group User
    ../: DataFlashProg.c descriptors.c main.c MassStorage.c
