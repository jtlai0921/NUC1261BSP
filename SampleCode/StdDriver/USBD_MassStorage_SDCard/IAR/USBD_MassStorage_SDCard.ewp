# IAR project USBD_MassStorage_SDCard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1261AE series Nuvoton NUC1261AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1261\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_MassStorage_SDCard.bin
  ILINK.IlinkOutputFile: USBD_MassStorage_SDCard.out
  ILINK.IlinkIcfFile: USBD_MassStorage_SDCard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1261/Source/IAR/: startup_NUC1261.s
    ../../../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c uart.c usbd.c
  group User
    ../: descriptors.c main.c MassStorage.c SDCard.c
