# IAR project USCI_UART_AutoBaudRate_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC126AE series Nuvoton NUC126AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1261\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USCI_UART_AutoBaudRate_Master.bin
  ILINK.IlinkOutputFile: USCI_UART_AutoBaudRate_Master.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1261/Source/IAR/: startup_NUC1261.s
    ../../../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usci_uart.c
  group User
    ../: main.c
